# Repository szepeu/klaar

## KiCad design kicad/flip.kicad_pcb

Board: 2 copper layers, 47.0 x 35.0 mm, 38 parts (32 on the bottom side), 35 nets.

Parts:
C0: J1; Jumper_SMD
C1: J2; Jumper_SMD
C2: J3; Jumper_SMD
C3: J4; Jumper_SMD
C4: J5; Jumper_SMD
C5: J6; Jumper_SMD
C6: J7; Jumper_SMD
C7: J8; Jumper_SMD
C8: J9; Jumper_SMD
C9: J10; Jumper_SMD
C10: J11; Jumper_SMD
C11: J12; Jumper_SMD
C12: J13; Jumper_SMD
C13: J14; Jumper_SMD
C14: J15; Jumper_SMD
C15: J16; Jumper_SMD
D1, D2: D_COIL; D_0805
G0: G4; Jumper_SMD
G1: G3; Jumper_SMD
G2: G1; Jumper_SMD
G3: G2; Jumper_SMD
HG1: Hall; Pin_Header_Straight_1x03_Pitch2.54mm
J1: HAL_TEST; Pin_Header_Straight_1x03_Pitch2.54mm
J2: IDC1; Socket_Strip_Straight_2x12_Pitch2.54mm
J3: COILS; TerminalBlock_Altech_AK300-3_P5.00mm
L1, L2: L; INDUCTOR_V
Q1, Q2, Q3, Q4: Q_NPN_BEC; SOT-23
R1, R4, R5, R6: 3k3; R_0603_HandSoldering
R2, R3: [10k]; R_0603_HandSoldering

Connections:
CH01: C0.1, J2.9
CH02: C1.1, J2.11
CH03: C2.1, J2.13
CH04: C3.1, J2.15
CH05: C4.1, J2.17
CH06: C5.1, J2.19
CH07: C6.1, J2.21
CH08: C7.1, J2.23
CH09: C8.1, J2.24
CH10: C9.1, J2.22
CH11: C10.1, J2.20
CH12: C11.1, J2.18
CH13: C12.1, J2.16
CH14: C13.1, J2.14
CH15: C14.1, J2.12
CH16: C15.1, J2.10
DIGITAL: C0.2, C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, HG1.3, J1.3, R2.2, R3.1
GND: J2.1, J2.4, Q1.2, Q2.2, Q3.2, Q4.2
GND0: G0.1, J2.5
GND1: G1.1, J2.7
GND2: G2.1, J2.8
GND3: G3.1, J2.6
unnamed: D1.1, D2.1, J3.2, L1.2, L2.1
unnamed: D1.2, J3.3, L1.1
unnamed: D2.2, J3.1, L2.2
unnamed: Q1.1, R1.1
unnamed: Q2.1, R4.1
unnamed: Q3.1, R5.1
unnamed: Q4.1, R6.1
SW_GND: HG1.2, J1.2, Q1.3, Q2.3, Q3.3, Q4.3, R3.2
SW_GND0: G2.2, R1.2
SW_GND1: G3.2, R5.2
SW_GND2: G1.2, R4.2
SW_GND3: G0.2, R6.2
VCC: HG1.1, J1.1, J2.2, J2.3, R2.1

## KiCad design Flip/flip.kicad_pcb

Parts:
D1, D2: D_COIL; D_0805
HG1: Hall; Pin_Header_Straight_1x03_Pitch2.54mm
J1: CHANNEL; Pin_Header_Straight_2x16_Pitch2.00mm
J2: COILS; TerminalBlock_Altech_AK300-3_P5.00mm
J3: IDC1; IDC_edge
J4: GROUND; Pin_Header_Straight_2x04_Pitch2.00mm
J5: HAL_TEST; Pin_Header_Straight_1x03_Pitch2.54mm
L1, L2: L; INDUCTOR_V
Q1, Q2, Q3, Q4: Q_NPN_BEC; SOT-23
R1, R2, R3, R4: 3k3; R_0603_HandSoldering
R5, R6: [10k]; R_0603_HandSoldering

Connections:
CH01: J1.1, J3.9
CH02: J1.3, J3.11
CH03: J1.5, J3.13
CH04: J1.7, J3.15
CH05: J1.9, J3.17
CH06: J1.11, J3.19
CH07: J1.13, J3.21
CH08: J1.15, J3.23
CH09: J1.17, J3.24
CH10: J1.19, J3.22
CH11: J1.21, J3.20
CH12: J1.23, J3.18
CH13: J1.25, J3.16
CH14: J1.27, J3.14
CH15: J1.29, J3.12
CH16: J1.31, J3.10
DIGITAL: HG1.3 (UH1), J1.2, J1.4, J1.6, J1.8, J1.10, J1.12, J1.14, J1.16, J1.18, J1.20, J1.22, J1.24, J1.26, J1.28, J1.30, J1.32, J5.3, R5.2, R6.1
GND: J3.1, J3.4, Q1.2 (E), Q2.2 (E), Q3.2 (E), Q4.2 (E)
GND0: J3.5, J4.7
GND1: J3.7, J4.5
GND2: J3.8, J4.1
GND3: J3.6, J4.3
unnamed: D1.1, D2.1, J2.2, L1.2, L2.1
unnamed: D1.2, J2.3, L1.1
unnamed: D2.2, J2.1, L2.2
unnamed: Q1.1 (B), R1.1
unnamed: Q2.1 (B), R2.1
unnamed: Q3.1 (B), R3.1
unnamed: Q4.1 (B), R4.1
SW_GND: HG1.2 (U2), J5.2, Q1.3 (C), Q2.3 (C), Q3.3 (C), Q4.3 (C), R6.2
SW_GND0: J4.2, R1.2
SW_GND1: J4.4, R3.2
SW_GND2: J4.6, R2.2
SW_GND3: J4.8, R4.2
VCC: HG1.1 (U1), J3.2, J3.3, J5.1, R5.1

Board: 2 copper layers, 95.0 x 62.0 mm, 20 parts (1 on the bottom side), 35 nets.

## Commit log

2018-06-25 initial commit - V2
2018-06-25 added mechanics
2018-06-25 new PCB WIP
2018-07-02 Changes in dir structure, small changes in the PCB
    Turns out it will be a good idea to have one PCB for both projects
2018-07-17 changed directory structure
2018-08-04 new PCB ready
2018-08-23 Modifications recommended by Karol
    Flip shorter by 7mm, wider by 0,5mm
2018-08-23 Initial version of flip with bearing
2018-10-13 Bearing project added
